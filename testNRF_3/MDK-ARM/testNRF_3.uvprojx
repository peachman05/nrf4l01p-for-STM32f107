# Keil uVision project testNRF_3.uvprojx, settings and files
target testNRF_3 Configuration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: testNRF_3 Configuration +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\nrf24l01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio_ex.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f107xc.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/nrf24l01
    ../nrf24l01/: nRF24L01p.c
software components: CMSIS:CORE 4.1.0
